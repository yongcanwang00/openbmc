FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Support-Celestica-Questone2-and-AS58XX-CL-projects.patch \
           "
